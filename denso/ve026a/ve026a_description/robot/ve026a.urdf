Commit message: updated tutorial arm

File: denso/ve026a/ve026a_description/robot/ve026a.urdf (robot description, URDF)
Before this commit: robot ve026a, 9 links, 8 joints
Links:
- link link7: geometry visual cylinder length=0.010 radius=0.005
